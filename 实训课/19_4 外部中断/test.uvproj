# Keil uVision project test.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware
  group Source Group 1
    ./: test.c
    ./Hardware/: ExpernalInterrupt.c ExpernalInterrupt.h
    ../13-3矩阵按键/Hardware/: Delay.c Delay.h
