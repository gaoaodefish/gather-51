# Keil uVision project test.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware
  group Source Group 1
    ./: test.c
    ../13-3矩阵按键/Hardware/: boot.h Delay.c Delay.h KeyMatrix.c KeyMatrix.h NixieLight.c NixieLight.h
    ./Hardware/: 28BYJ_48.c 28BYJ_48.h
