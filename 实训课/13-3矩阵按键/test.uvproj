# Keil uVision project test.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware
  group Source Group 1
    ./: test.c
    ./HardWare/: Delay.c
    ./Hardware/: Delay.h NixieLight.c NixieLight.h KeyMatrix.c KeyMatrix.h boot.h
